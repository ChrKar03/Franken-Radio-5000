options:
  parameters:
    author: chrisos
    generate_options: qt_gui
    id: rx
    output_language: python
    title: rx
  states: {}

blocks:
- name: channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: squelch
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: tx_enable
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_trans
  id: variable
  parameters:
    value: 1 if not squelch and tx_enable else 0
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 2.5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: 2.5e3
    interp: '1'
    low_cutoff_freq: '300'
    samp_rate: 48e3
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_enable
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.02'
    init: '0'
    low: '0.005'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import RPi.GPIO as GPIO
      import threading
      import time

      class blk(gr.sync_block):
          """
          Pi GPIO Controller for SDR:
          - TX button: momentary transmit
          - Channel button: single click forward, double click backward
          - Gain button: single click up, double click down
          - LED: on when receiving or transmitting
          """

          def __init__(self, tx_pin=17, chan_pin=27, gain_pin=22, led_pin=23):
              # sdr_source and sdr_sink are SDR blocks you want to control
              gr.sync_block.__init__(self,
                  name="Pi 5 GPIO Controller",
                  in_sig=[np.float32],  # input from SDR
                  out_sig=None  # pass through for audio if needed
              )

              self.parent = None

              # GPIO pins
              self.TX_PIN = tx_pin
              self.CHAN_PIN = chan_pin
              self.GAIN_PIN = gain_pin
              self.LED_PIN = led_pin

              # Variables
              self.running = False
              self.tx_trans = 0
              self.chan_list = [0, 12500, 25000]
              self.gain_list = [4, 8, 16, 32, 64]
              self.chan_idx = 0
              self.gain_idx = 0
              self.channel = self.chan_list[self.chan_idx]
              self.rx_gain = self.gain_list[self.gain_idx]

              # Debounce / button thread lock
              self.lock = threading.Lock()

          # ------------------------
          # Button utilities
          # ------------------------
          def detect_clicks(self, pin, timeout=0.4):
              """Detects single or double clicks on a button."""
              count = 0
              start_time = time.time()
              while time.time() - start_time < timeout:
                  if GPIO.input(pin) == GPIO.HIGH:
                      count += 1
                      while GPIO.input(pin) == GPIO.HIGH:
                          time.sleep(0.01)  # wait for release
                      time.sleep(0.01)  # debounce
              return count

          def button_thread(self):
              while self.running:
                  # ----------------
                  # TX Button
                  # ----------------
                  tx_state = 1 if GPIO.input(self.TX_PIN) == GPIO.HIGH else 0
                  with self.lock:
                      self.parent.set_tx_enable(tx_state)

                  # ----------------
                  # Channel Button
                  # ----------------
                  if GPIO.input(self.CHAN_PIN) == GPIO.HIGH:
                      clicks = self.detect_clicks(self.CHAN_PIN)
                      step = 1 if clicks == 1 else -1 if clicks >= 2 else 0
                      with self.lock:
                          self.chan_idx = (self.chan_idx + step) % len(self.chan_list)
                          self.channel = self.chan_list[self.chan_idx]
                          # Update SDR source frequency
                          self.parent.set_channel(self.channel)
                      print(f"[Channel] New frequency: {self.channel}")

                  # ----------------
                  # Gain Button
                  # ----------------
                  if GPIO.input(self.GAIN_PIN) == GPIO.HIGH:
                      clicks = self.detect_clicks(self.GAIN_PIN)
                      step = 1 if clicks == 1 else -1 if clicks >= 2 else 0
                      with self.lock:
                          self.gain_idx = (self.gain_idx + step) % len(self.gain_list)
                          self.rx_gain = self.gain_list[self.gain_idx]
                          # Update SDR source gain
                          self.parent.set_rx_gain(self.rx_gain)
                      print(f"[Gain] New RX gain: {self.rx_gain}")

                  time.sleep(0.05)

          # ------------------------
          # GNU Radio work function
          # ------------------------
          def work(self, input_items, output_items):
              # Determine receiving based on input RMS
              rms = np.sqrt(np.mean(np.square(input_items[0])))
              is_receiving = rms > 0.001  # adjust threshold if needed

              # TX state from thread
              with self.lock:
                  is_transmitting = self.tx_trans

              light_on = is_transmitting and not is_receiving or not is_transmitting and is_receiving

              # LED control
              GPIO.output(self.LED_PIN, GPIO.HIGH if light_on else GPIO.LOW)

              return len(input_items[0])

          # ------------------------
          # Start/Stop
          # ------------------------
          def start(self):
              GPIO.setmode(GPIO.BCM)
              GPIO.setup([self.TX_PIN, self.CHAN_PIN, self.GAIN_PIN], GPIO.IN, pull_up_down=GPIO.PUD_DOWN)
              GPIO.setup(self.LED_PIN, GPIO.OUT)

              self.running = True
              self.thread = threading.Thread(target=self.button_thread, daemon=True)
              self.thread.start()
              return super().start()

          def stop(self):
              self.running = False
              if hasattr(self, 'thread') and self.thread.is_alive():
                  self.thread.join()
              GPIO.cleanup()
              return super().stop()
    chan_pin: '27'
    gain_pin: '22'
    led_pin: '23'
    tx_pin: '17'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: 0 if tx_trans else -80
    bandwidth: '200000'
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '446000000'
    samplerate: '768000'
    type: fc32
    uri: '"192.168.3.1"'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '4096'
    filter_source: '''Auto'''
    frequency: 446000000 + channel
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '768000'
    type: fc32
    uri: '"192.168.3.1"'
  states: {}
- name: note_0
  id: note
  parameters:
    note: TX PATH
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: RX PATH
  states: {}
- name: probe_signal
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 48e3
    fc: '0'
    fftsize: '1024'
    name: '"rx_input"'
    rate: '2'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: 768e3
    fc: '0'
    fftsize: '1024'
    name: '"tx_output"'
    rate: '2'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_nbfm_rx_0, '0', band_pass_filter_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_0, '0', blocks_rms_xx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0, '0', probe_signal, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0_0, '0']
- [rational_resampler_xxx_1, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
